define symbol __entry = reset_handler;
define region FLASH = mem:[from 0x08000000 to 0x0807FFFF];
already hand-written
